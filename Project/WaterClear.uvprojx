# Keil uVision project WaterClear.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: WaterClear +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\Hardware;..\Library\Include;..\StartUp;..\User;..\Hardware\GSM;..\Hardware\TDS;..\Hardware\Uart;..\Hardware\Pressure;..\Hardware\Flow
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Library
    ../Library/Source/: hr8p506_iap_table.c lib_adc.c lib_euart.c lib_flashiap.c lib_gpio.c lib_iic.c lib_lcd.c lib_led.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group User
    ../User/: main.c my_systick.c msgbuild.c
  group Startup
    ../StartUp/: startup_HR8P506.s system_HR8P506.c
  group Hardware
    ../Hardware/TDS/: tds.c
    ../Hardware/Uart/: uart.c
    ../Hardware/GSM/: sim800c.c
    ../Hardware/Pressure/: pressure.c
    ../Hardware/Flow/: water_flow.c
